# Keil uVision project stm32g030_rtos.uvprojx, settings and files
target STM32G030F6P6 (6220000::V6.22::ARMCLANG)
  device: STM32G030F6Px STMicroelectronics
  pack: Keil.STM32G0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: stm32g030_rtos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group inc
    ./: gpio.h debug.h c_test.h asm_test.h cdefs.h wdt.h
  group src
    ./: main.c gpio.c debug.c c_test.c asm_test.s wdt.c
  group Device
    ./RTE/Device/: startup_stm32g030xx.s system_stm32g0xx.c
  group FRTOS
    ./: kernel.h kernel.s threads.h threads.c
software components: CMSIS:CORE 6.2.0
